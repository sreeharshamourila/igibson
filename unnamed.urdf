Commit message: Add files via upload

File: unnamed.urdf (robot description, URDF)
Before this commit: robot unnamed, 1 links, 0 joints
Links:
- removed link Plane
